# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PLC2STM +hex
  AfterMake: ..\OBJ\srec_cat ..\OBJ\PLC2STM.hex -intel -crop 0x800F000 0x800FFF8  ..\OBJ\PLC2STM.hex   -Intel -exclude 0x80F000 0x8010000 -STM32_Little_Endian  0x800FFFC  -Exclusive-Length_Little_Endian 0x800FFF8  -o ..\OBJ\PLC2STMWithCRC.hex -intel
  AfterMake: ..\OBJ\srec_cat ..\OBJ\PLC2STMWithCRC.hex -Intel -offset -0x800F000 -o ..\OBJ\PLC2STM_Vxx.bin -Binary
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE = 8000000
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE;..\USER;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\BSP;..\TASK;..\APP;..\FATFS;..\..\STM32F4xx_StdPeriph_Driver\inc;..\FatFs\source
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\OBJ\PLC2STM.sct
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group README
    ../: readme.txt
  group BSP
    ../BSP/: bsp_fifo.c bsp_SHT2x.c bsp_ds3231.c sdio_sdcard.c stmflash.c bsp_adc.c bsp_cfg.c bsp_tim.c bsp_gpio.c bsp_port.c bsp_rtc.c bsp_bm8563.c
  group HARDWARE
    ../HARDWARE/: iic2.c spi1.c iic1.c iic3.c sram.c spi3.c
  group APP
    ../APP/: app_cmd.c app_debug.c app_env.c iap.c app_GBcmd.c alarm.c stack.c iwdg.c float.c app_led.c protocol.c app_measure.c app_port.c app_adc.c kalmanFilter.c app_sd.c app_com_sub.c app_flow.c app_database.c app_bushui.c app_baohu.c app_bushui_andan.c
  group FWLib
    ../../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group FatFs
    ../FatFs/source/: diskio.c ff.c ffsystem.c ffunicode.c
